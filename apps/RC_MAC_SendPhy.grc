options:
  parameters:
    category: '[Rc_mac]'
    generate_options: hb
    id: RC_MAC_PHY_Sender
    output_language: python
  states: {}

blocks:
- name: TX_gain
  id: variable
  parameters:
    value: '60'
  states: {}
- name: bw
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 433e6
  states: {}
- name: cr
  id: variable
  parameters:
    value: '3'
  states: {}
- name: frame_period
  id: variable
  parameters:
    value: '3000'
  states: {}
- name: has_crc
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: impl_head
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: bw
  states: {}
- name: sf
  id: variable
  parameters:
    value: '7'
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("hello world")
    period: frame_period
  states: {state: disabled}
- name: blocks_message_strobe_0_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.dict_add(pmt.make_dict(),pmt.intern("sf"),pmt.from_uint64(sf))
    period: frame_period
  states: {state: disabled}
- name: lora_sdr_SendRecordParam_0
  id: lora_sdr_SendRecordParam
  parameters:
    nodeId: '4'
  states: {}
- name: lora_sdr_add_crc_0
  id: lora_sdr_add_crc
  parameters:
    has_crc: has_crc
  states: {}
- name: lora_sdr_gray_decode_0
  id: lora_sdr_gray_decode
  parameters:
    sf: nodesf
  states: {}
- name: lora_sdr_hamming_enc_0
  id: lora_sdr_hamming_enc
  parameters:
    cr: nodecr
    sf: nodesf
  states: {}
- name: lora_sdr_header_0
  id: lora_sdr_header
  parameters:
    cr: nodecr
    has_crc: has_crc
    impl_head: impl_head
  states: {}
- name: lora_sdr_interleaver_0
  id: lora_sdr_interleaver
  parameters:
    cr: nodecr
    sf: nodesf
  states: {}
- name: lora_sdr_messageStrobeLoRa_0
  id: lora_sdr_messageStrobeLoRa
  parameters:
    day: '16'
    hour: '14'
    min: '47'
    mon: '11'
    msg: pmt.intern("hello world")
    period_ms: '1000'
    sec: '0'
    year: '122'
  states: {state: disabled}
- name: lora_sdr_modulate_0
  id: lora_sdr_modulate
  parameters:
    bw: nodebw
    minoutbuf: '10000000'
    samp_rate: samp_rate
    sf: nodesf
    sync_words: '[8,16]'
  states: {}
- name: lora_sdr_whitening_0
  id: lora_sdr_whitening
  parameters: {}
  states: {}
- name: nodeSampRate
  id: parameter
  parameters:
    label: nodeSampRate
    value: '250000'
  states: {}
- name: nodebw
  id: parameter
  parameters:
    label: nodebw
    value: '250000'
  states: {}
- name: nodecr
  id: parameter
  parameters:
    label: nodecr
    value: '3'
  states: {}
- name: nodesf
  id: parameter
  parameters:
    label: nodesf
    value: '7'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: message
  states: {}

connections:
- [blocks_message_strobe_0, strobe, lora_sdr_whitening_0, msg]
- [blocks_message_strobe_0_0, strobe, lora_sdr_gray_decode_0, inSF]
- [blocks_message_strobe_0_0, strobe, lora_sdr_hamming_enc_0, inSF]
- [blocks_message_strobe_0_0, strobe, lora_sdr_interleaver_0, inSF]
- [blocks_message_strobe_0_0, strobe, lora_sdr_modulate_0, inSF]
- [lora_sdr_add_crc_0, '0', lora_sdr_hamming_enc_0, '0']
- [lora_sdr_gray_decode_0, '0', lora_sdr_modulate_0, '0']
- [lora_sdr_hamming_enc_0, '0', lora_sdr_interleaver_0, '0']
- [lora_sdr_header_0, '0', lora_sdr_add_crc_0, '0']
- [lora_sdr_interleaver_0, '0', lora_sdr_gray_decode_0, '0']
- [lora_sdr_messageStrobeLoRa_0, strobe, lora_sdr_whitening_0, msg]
- [lora_sdr_modulate_0, '0', pad_sink_0, '0']
- [lora_sdr_modulate_0, outPara, lora_sdr_SendRecordParam_0, endIn]
- [lora_sdr_whitening_0, '0', lora_sdr_header_0, '0']
- [lora_sdr_whitening_0, paraOut, lora_sdr_SendRecordParam_0, StartIn]
- [pad_source_0, out, lora_sdr_whitening_0, msg]

metadata:
  file_format: 1
