options:
  parameters:
    author: zjhao
    category: '[Rc_mac]'
    generate_options: hb
    id: rc_mac_phy_receiver
    output_language: python
  states: {}

blocks:
- name: bw
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 433e6
  states: {}
- name: cr
  id: variable
  parameters:
    value: '3'
  states: {}
- name: frame_period
  id: variable
  parameters:
    value: '3000'
  states: {}
- name: has_crc
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: impl_head
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: pay_len
  id: variable
  parameters:
    value: '11'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 250e3
  states: {}
- name: sf
  id: variable
  parameters:
    value: '7'
  states: {}
- name: channelsf
  id: parameter
  parameters:
    label: sf
    type: intx
    value: '7'
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '4'
    taps: (-0.128616616593872,    -0.212206590789194,    -0.180063263231421,    3.89817183251938e-17    ,0.300105438719035    ,0.636619772367581    ,0.900316316157106,    1    ,0.900316316157106,    0.636619772367581,    0.300105438719035,    3.89817183251938e-17,    -0.180063263231421,    -0.212206590789194,    -0.128616616593872)
    type: ccf
  states: {}
- name: lora_sdr_crc_verif_0
  id: lora_sdr_crc_verif
  parameters:
    frequency: center_freq
    sf: channelsf
  states: {}
- name: lora_sdr_deinterleaver_0
  id: lora_sdr_deinterleaver
  parameters:
    sf: channelsf
  states: {}
- name: lora_sdr_dewhitening_0
  id: lora_sdr_dewhitening
  parameters: {}
  states: {}
- name: lora_sdr_fft_demod_0
  id: lora_sdr_fft_demod
  parameters:
    impl_head: impl_head
    sf: channelsf
  states: {}
- name: lora_sdr_frame_sync_0
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: bw
    impl_head: impl_head
    samp_rate: ''
    sf: channelsf
    sync_word: '0x12'
  states: {}
- name: lora_sdr_gray_enc_0
  id: lora_sdr_gray_enc
  parameters: {}
  states: {}
- name: lora_sdr_hamming_dec_0
  id: lora_sdr_hamming_dec
  parameters: {}
  states: {}
- name: lora_sdr_header_decoder_0
  id: lora_sdr_header_decoder
  parameters:
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
    pay_len: '50'
  states: {}
- name: lora_sdr_readParam_0
  id: lora_sdr_readParam
  parameters:
    bw: bw
    samp_rate: samp_rate
    sf: channelsf
  states: {}
- name: lora_sdr_recordParams_0
  id: lora_sdr_recordParams
  parameters: {}
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: message
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}

connections:
- [interp_fir_filter_xxx_0, '0', lora_sdr_readParam_0, '0']
- [lora_sdr_crc_verif_0, msg, lora_sdr_recordParams_0, msgIn]
- [lora_sdr_crc_verif_0, msg, pad_sink_0, in]
- [lora_sdr_deinterleaver_0, '0', lora_sdr_hamming_dec_0, '0']
- [lora_sdr_dewhitening_0, '0', lora_sdr_crc_verif_0, '0']
- [lora_sdr_fft_demod_0, '0', lora_sdr_gray_enc_0, '0']
- [lora_sdr_frame_sync_0, '0', lora_sdr_fft_demod_0, '0']
- [lora_sdr_gray_enc_0, '0', lora_sdr_deinterleaver_0, '0']
- [lora_sdr_hamming_dec_0, '0', lora_sdr_header_decoder_0, '0']
- [lora_sdr_header_decoder_0, '0', lora_sdr_dewhitening_0, '0']
- [lora_sdr_header_decoder_0, frame_info, lora_sdr_frame_sync_0, frame_info]
- [lora_sdr_readParam_0, '0', lora_sdr_frame_sync_0, '0']
- [lora_sdr_readParam_0, SNROut, lora_sdr_recordParams_0, SNRIN]
- [pad_source_0, '0', interp_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
