options:
  parameters:
    author: zjhao
    generate_options: no_gui
    id: RTSSender
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bw
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: classType
  id: variable
  parameters:
    value: '1'
  states: {}
- name: frequency
  id: variable
  parameters:
    value: '433000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: sf
  id: variable
  parameters:
    value: '7'
  states: {}
- name: RC_MAC_PHY_Sender_0
  id: RC_MAC_PHY_Sender
  parameters: {}
  states: {}
- name: RC_MAC_RTSSender_0
  id: RC_MAC_RTSSender
  parameters:
    NodeId: '1'
    bw: '250000'
    classType: '1'
    filename: RTSNode1.txt
    sampRate: '250000'
    sf: '7'
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("hello world")
    period: '1000'
  states: {state: disabled}
- name: blocks_message_strobe_random_0
  id: blocks_message_strobe_random
  parameters:
    dist: blocks.STROBE_UNIFORM
    mean: '200'
    msg: pmt.intern("hello world,my name is node 1!")
    std: '10'
  states: {}
- name: rc_mac_phy_receiver_0
  id: rc_mac_phy_receiver
  parameters:
    channelsf: '7'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    bw0: '250000'
    center_freq0: '433000000'
    dev_addr: '"serial=3241A4A"'
    dev_args: '""'
    gain0: '90'
    len_tag_name: frame_len
    norm_gain0: 'False'
    samp_rate: samp_rate
    sd_spec0: A:B
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    bw0: bw
    center_freq0: frequency
    dc_offs_enb0: '""'
    dev_addr: '"serial=3241A4A"'
    dev_args: '""'
    gain0: '60'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [RC_MAC_PHY_Sender_0, '0', uhd_usrp_sink_0, '0']
- [RC_MAC_RTSSender_0, UserDataOut, RC_MAC_PHY_Sender_0, in]
- [blocks_message_strobe_random_0, strobe, RC_MAC_RTSSender_0, UserDataIn]
- [rc_mac_phy_receiver_0, out, RC_MAC_RTSSender_0, DecodeMessage]
- [uhd_usrp_source_0, '0', RC_MAC_RTSSender_0, '0']
- [uhd_usrp_source_0, '0', rc_mac_phy_receiver_0, '0']

metadata:
  file_format: 1
