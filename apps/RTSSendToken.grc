options:
  parameters:
    author: zjhao
    generate_options: qt_gui
    id: SendToken
    output_language: python
    title: SendToken
  states: {}

blocks:
- name: bw
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '433000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: bw
  states: {}
- name: sf
  id: variable
  parameters:
    value: '7'
  states: {}
- name: RC_MAC_RTSSendToken_0
  id: RC_MAC_RTSSendToken
  parameters:
    bw: bw
    nodeToken: '1'
    samp_rate: samp_rate
    sf: sf
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '10000'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [RC_MAC_RTSSendToken_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_message_strobe_0, strobe, RC_MAC_RTSSendToken_0, RTSToken]

metadata:
  file_format: 1
