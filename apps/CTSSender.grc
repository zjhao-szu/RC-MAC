options:
  parameters:
    author: zjhao
    generate_options: no_gui
    id: CTSSender
    output_language: python
    title: CTSSender
  states: {}

blocks:
- name: bw
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: classType
  id: variable
  parameters:
    value: '1'
  states: {}
- name: frequency
  id: variable
  parameters:
    value: '433000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: sf
  id: variable
  parameters:
    value: '7'
  states: {}
- name: RC_MAC_CTSSender_0
  id: RC_MAC_CTSSender
  parameters:
    bw: bw
    classType: classType
    sampRate: samp_rate
    sf: sf
  states: {state: disabled}
- name: RC_MAC_CTSSender_1
  id: RC_MAC_CTSSender
  parameters:
    bw: bw
    classType: '1'
    sampRate: samp_rate
    sf: sf
  states: {}
- name: RC_MAC_PHY_Sender_0
  id: RC_MAC_PHY_Sender
  parameters: {}
  states: {state: disabled}
- name: RC_MAC_PHY_Sender_0_0
  id: RC_MAC_PHY_Sender
  parameters: {}
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: rc_mac_phy_0
  id: rc_mac_phy
  parameters: {}
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    bw0: bw
    center_freq0: frequency
    dev_addr: '"serial=32419E7"'
    dev_args: '""'
    gain0: '60'
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    bw0: '250000'
    center_freq0: '433000000'
    dev_addr: '"serial=32419E7"'
    dev_args: '""'
    gain0: '90'
    len_tag_name: frame_len
    norm_gain0: 'False'
    samp_rate: samp_rate
    sd_spec0: A:B
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    bw0: bw
    center_freq0: frequency
    dc_offs_enb0: '""'
    dev_addr: '"serial=32419E7"'
    dev_args: '""'
    gain0: '70'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [RC_MAC_CTSSender_0, OutCTS, RC_MAC_PHY_Sender_0, in]
- [RC_MAC_CTSSender_0, OutData, RC_MAC_PHY_Sender_0, in]
- [RC_MAC_CTSSender_1, OutData, RC_MAC_PHY_Sender_0_0, in]
- [RC_MAC_PHY_Sender_0, '0', uhd_usrp_sink_0, '0']
- [RC_MAC_PHY_Sender_0_0, '0', uhd_usrp_sink_0_0, '0']
- [rc_mac_phy_0, out, RC_MAC_CTSSender_1, receiveData]
- [uhd_usrp_source_0, '0', RC_MAC_CTSSender_1, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [uhd_usrp_source_0, '0', rc_mac_phy_0, '0']

metadata:
  file_format: 1
